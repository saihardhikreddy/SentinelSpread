options:
  parameters:
    author: SentinelSpread Team
    description: SentinelSpread GNU Radio Software SDR Loopback
    generate_options: no_gui
    id: sentinelspread_flowgraph
    output_language: python
    run_options: run
    title: SentinelSpread GNU Radio Software SDR Loopback
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: spreading_factor
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: filter.firdes.root_raised_cosine(2.0, 4.0, 1.0, 0.35, 41)
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import sentinelspread.gnuradio.blocks as ssb

      class blk(gr.sync_block):
          def __init__(self, message='SentinelSpread GNU Radio SDR Software Loopback Verification 2026', spreading_factor=16):
              gr.sync_block.__init__(self, name='crypto_dsss_tx', in_sig=None, out_sig=[np.complex64])
              self.impl = ssb.crypto_dsss_tx(message=message, spreading_factor=spreading_factor)
          def work(self, input_items, output_items):
              return self.impl.work(input_items, output_items)
    message: '''SentinelSpread GNU Radio SDR Software Loopback Verification 2026'''
    spreading_factor: spreading_factor
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.02'
    seed: '42'
    taps: 1.0 + 0.0j
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.0628'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import sentinelspread.gnuradio.blocks as ssb
      import pmt

      class blk(gr.sync_block):
          def __init__(self, expected_message='SentinelSpread GNU Radio SDR Software Loopback Verification 2026', spreading_factor=16):
              gr.sync_block.__init__(self, name='dsss_crypto_rx', in_sig=[np.complex64], out_sig=None)
              self.impl = ssb.dsss_crypto_rx(expected_message=expected_message, spreading_factor=spreading_factor)
              self.message_port_register_out(pmt.intern('msg_out'))
          def work(self, input_items, output_items):
              return self.impl.work(input_items, output_items)
          def stop(self):
              self.impl.stop()
              return super().stop()
    expected_message: '''SentinelSpread GNU Radio SDR Software Loopback Verification 2026'''
    spreading_factor: spreading_factor
  states: {}

connections:
- [epy_block_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', interp_fir_filter_xxx_0, '0']
- [interp_fir_filter_xxx_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_costas_loop_cc_0, '0', epy_block_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
